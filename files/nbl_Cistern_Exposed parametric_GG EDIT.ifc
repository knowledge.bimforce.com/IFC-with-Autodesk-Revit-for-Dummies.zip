Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [notYetAssigned]
File name: C:\My Work\Geometry Gym\documents\ssi\BIM\ifc\external\national bim library\nbl_Cistern_Exposed parametric.ifc
Time: 2013-10-05T19:35:15
Author: Jon
Organization: Unknown
Written by: ssiRhinoIFC - Rhino Plug-in by Geometry Gym Pty Ltd
Made in: ssiRhinoIFC - Rhino Plug-in by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Organization Description: DEFAULT; Author: DEFAULT; Building Name: DEFAULT; Organization Name: DEFAULT
Other - Project Name: Project Name; Project Address: Enter address here; Client Name: Owner; Project Issue Date: Issue Date; Project Status: Project Status; Project Number: Project Number

# IfcBuildingStorey, Level 0
LongName: Level 0
Constraints - Elevation: 0 mm; Elevation Base: 0
Identity Data - Building Story: yes; Structural: no; Name: Level 0
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: Centre; Symbol: Level Head - Circle: Level Head - Circle; Symbol at End 2 Default: no; Line Weight: 1; Symbol at End 1 Default: yes; Color: 0

# IfcFlowTerminal: 450x200x350, nbl_Cistern_Exposed:450x200x350:450x200x350:213265
In: Level 0
Type - ElementType: 450x200x350; PredefinedType: CISTERN; Classification:  (UniFormat)
Material: nbl_ConceptSolid
Constraints - Offset: 0 mm; Level: Level: Level 0; Host: Level : Level 0
Identity Data - ComponentNumber: DEFAULT; SanitarywareSet: DEFAULT; Mark: 1; Help: www.nationalbimlibrary.com; Assembly Description: DEFAULT; URL: www.nationalbimlibrary.com; OmniClass Title: DEFAULT; Description: Exposed cistern assembly; OmniClass Number: DEFAULT; Version: 1.0; NBSReference: Varies; NBSDescription: Varies; Assembly Code: DEFAULT; IssueDate: 12/06/29
Construction - FlushpipeCurved: yes; FlushpipeStraight: no
Other - AssetIdentifier: DEFAULT; WarrantyStartDate: DEFAULT; BarCode: DEFAULT; SerialNumber: DEFAULT; InstallationDate: DEFAULT; TagNumber: DEFAULT; Features: DEFAULT; Size: DEFAULT; Shape: DEFAULT; WarrantyDurationLabour: DEFAULT; ServiceLifeDuration: DEFAULT; NominalWidth: 450 mm; Colour: DEFAULT; SustainabilityPerformance: DEFAULT; WarrantyDescription: DEFAULT; AccessibilityPerformance: DEFAULT; CodePerformance: DEFAULT; Constituents: DEFAULT; ReplacementCost: DEFAULT; WarrantyGuarantorLabour: DEFAULT; NominalLength: 200 mm; Grade: DEFAULT; Finish: DEFAULT; ProductionYear: DEFAULT; WarrantyDurationParts: DEFAULT; WarrantyGuarantorParts: DEFAULT; NominalHeight: 350 mm; Material: DEFAULT
Dimensions - OffsetFromFloor: 350 mm; FlushpipeLength: 180 mm; FlushpipeHeight: 200 mm; FlushpipeRadius: 15 mm; Width: 450 mm; FlushpipeOffset: 75 mm; Length: 200 mm; Height: 350 mm; Depth: 200 mm
Mechanical - System Classification: Sanitary; System Name: DEFAULT; System Abbreviation: DEFAULT
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - ProductionYear: DEFAULT
Materials and Finishes - ExposedCisternMaterial: nbl_ConceptSolid; FlushpipeMaterial: nbl_ConceptSolid
Plumbing - CW Connection: no; ColdWaterOutletDiameter: 30 mm; ColdWaterSupplyRadius: 10 mm; ColdWaterSupplyDiameter: 20 mm; ColdWaterOutletRadius: 15 mm
