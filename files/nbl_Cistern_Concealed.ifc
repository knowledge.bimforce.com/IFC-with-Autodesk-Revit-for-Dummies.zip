Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: nbl_Cistern_Concealed.ifc
Time: 2012-07-11T14:23:42
Written by: Xbim Toolkit 2012
Made in: 20120221_2030(x64)

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Project Name: Project Name; Project Number: Project Number; Project Issue Date: Issue Date; Project Status: Project Status; Client Name: Owner; Project Address: Enter address here

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Graphics - Color: 0; Symbol at End 2 Default: no; Symbol: Level Head - Circle: Level Head - Circle; Symbol at End 1 Default: yes; Line Weight: 1; Line Pattern: Centre
Constraints - Elevation Base: 0; Elevation: 0 mm
Identity Data - Name: Level 0; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: 450x150x350, nbl_Cistern_Concealed:450x150x350:450x150x350:213265
In: Level 0
Type - ElementType: 450x150x350; PredefinedType: CISTERN; Classification:  (UniFormat)
Material: nbl_ConceptSolid
Identity Data - Mark: 1; URL: www.nationalbimlibrary.com; NBSDescription: Varies; Help: www.nationalbimlibrary.com; NBSReference: Varies; IssueDate: 12/06/29; Version: 1.0; Description: Concealed cistern assembly
Dimensions - OffsetFromFloor: 350 mm; FlushpipeLength: 200 mm; FlushpipeHeight: 400 mm; FlushpipeRadius: 15 mm; Width: 450 mm; Depth: 150 mm; Height: 350 mm; FlushpipeOffset: 75 mm; Length: 150 mm
Mechanical - System Classification: Sanitary
Constraints - Offset: 0 mm; Host: Level : Level 0; Level: Level: Level 0
Phasing - Phase Created: New Construction
Other - NominalHeight: 350 mm; NominalWidth: 450 mm; NominalLength: 150 mm
Plumbing - CW Connection: no; ColdWaterSupplyRadius: 10 mm; ColdWaterOutletRadius: 15 mm; ColdWaterSupplyDiameter: 20 mm; ColdWaterOutletDiameter: 30 mm
Materials and Finishes - ConcealedCisternMaterial: nbl_ConceptSolid; FlushpipeMaterial: nbl_ConceptSolid
